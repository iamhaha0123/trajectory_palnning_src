Commit message: 加入fk_node和camera_frame

File: lrmate_200id-main/urdf/LRMate-200iD_convex.urdf (robot description, URDF)
Before this commit: robot lrmate-200id, 8 links, 7 joints
Joints:
- joint base_fixed: origin xyz=0 0 0.811 rpy=0 0 0 -> xyz=-0.002 0.1215 0.811 rpy=0 0 0
